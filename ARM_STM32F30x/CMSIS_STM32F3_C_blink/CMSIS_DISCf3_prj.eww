<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CMSIS_DISCf3_prj.ewp</path>
    </project>
    <batchBuild />
</workspace>
